Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2016-12-07T13:38:40
Author: Katajamäki, Jokke
Organization: WSP Finland
Made in: ASIFC - 2.5.4.645

# IfcProject
LongName: D1_HKR_penkit, terasjalka

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBeam (3)
In: Site
Description: RST 146x60

# IfcEquipmentElement (4)
In: Site
Description: RST, 70 x 7

# IfcFooting, TASSU
In: Site
Description: RST 200 x 120 x 6

# IfcFurnishingElement (20)
In: Site
Name | Description
13 x PUURIMA 43x43x1850, istuinosa | tiheäsyinen mänty tai tammi / kuultokäsittely tai peittomaalaus / Värit: (Kivikaupunki Valtti color 3145, RAL 7021 tai RAL 8015) (Aluekeskus ja asuinalue RAL 7021 tai RAL 8015)
2 x PUURIMA, istuinosa | tiheäsyinen mänty tai tammi / kuultokäsittely tai peittomaalaus / Värit: (Kivikaupunki Valtti color 3145, RAL 7021 tai RAL 8015) (Aluekeskus ja asuinalue RAL 7021 tai RAL 8015)
2 x 
TERÄSLATTA, käsinoja | RST 70 x 7
TASSU | RST 200 x 120 x 6
PUURIMA 28x70x330, käsinoja | tiheäsyinen mänty tai tammi / kuultokäsittely tai peittomaalaus / Värit: (Kivikaupunki Valtti color 3145, RAL 7021 tai RAL 8015) (Aluekeskus ja asuinalue RAL 7021 tai RAL 8015)
